# Keil uVision project STB.uvprojx, settings and files
target STB (ARM-ADS)
  device: STM32F205RF STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80BFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STB
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx
  c include: ../Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f2xx.c
  group Application/User
    ../Src/: stm32f2xx_it.c stm32f2xx_hal_msp.c main.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_tim.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_irda.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_dma.c stm32f2xx_hal_spi.c stm32f2xx_hal.c
software components: CMSIS:CORE 4.3.0
